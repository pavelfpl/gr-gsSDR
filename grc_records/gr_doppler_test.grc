options:
  parameters:
    author: Daniel Estevez, M0HXM
    category: Custom
    description: GNUradio Doppler correction module
    generate_options: qt_gui
    id: gr_doppler_test
    output_language: python
    title: gr-doppler
  states: {}

blocks:
- name: doppler
  id: variable
  parameters:
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: 437.525e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq-doppler
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:1,0
    num_inputs: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lucky-7.iq
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler
  states: {}
- name: gpredict_doppler_0
  id: gpredict_doppler
  parameters:
    gpredict_host: localhost
    gpredict_port: '4532'
    verbose: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_lucky7_deframer_0
  id: satellites_lucky7_deframer
  parameters:
    threshold: '10'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '45'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [gpredict_doppler_0, freq, blocks_message_debug_1, print]
- [gpredict_doppler_0, freq, gpredict_MsgPairToVar_0, inpair]
- [satellites_fsk_demodulator_0, '0', satellites_lucky7_deframer_0, '0']
- [satellites_lucky7_deframer_0, out, blocks_message_debug_0, print_pdu]
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
