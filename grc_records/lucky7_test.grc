options:
  parameters:
    generate_options: no_gui
    id: lucky7_test
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pavelf/gnuradio_addons_3.8/gr-gsSDR/grc_records/example_records/lucky_7.wav
    repeat: 'True'
  states: {}
- name: gsSDR_http_transfer_sink_0
  id: gsSDR_http_transfer_sink
  parameters:
    ServerName: localhost
    ServerPort: '8080'
    ServerTarget: /gs/tm
    UserName: ''
    UserPass: ''
    spacecraftId: '1'
    stationId: '10'
  states: {}
- name: gsSDR_http_transfer_source_0
  id: gsSDR_http_transfer_source
  parameters:
    ServerName: localhost
    ServerPort: '8080'
    ServerTarget: /gs/tc
    UserName: ''
    UserPass: ''
    spacecraftId: '0'
    stationId: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_lucky7_deframer_0
  id: satellites_lucky7_deframer
  parameters:
    options: ''
    threshold: '0'
  states: {}

connections:
- [blocks_throttle_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [gsSDR_http_transfer_source_0, out, blocks_message_debug_0_0, print_pdu]
- [satellites_fsk_demodulator_0, '0', satellites_lucky7_deframer_0, '0']
- [satellites_lucky7_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_lucky7_deframer_0, out, gsSDR_http_transfer_sink_0, in]

metadata:
  file_format: 1
