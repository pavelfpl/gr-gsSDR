options:
  parameters:
    generate_options: qt_gui
    id: lucky7_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pavelf/satellites_record/example_records/lucky_7.wav
    repeat: 'False'
  states: {}
- name: gsSDR_websocket_transfer_sink_1
  id: gsSDR_websocket_transfer_sink
  parameters:
    ServerName: 178.128.160.180
    ServerPort: '8002'
    UserName: ''
    UserPass: ''
    stationId: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_lucky7_deframer_0
  id: satellites_lucky7_deframer
  parameters:
    options: ''
    threshold: '0'
  states: {}

connections:
- [blocks_throttle_0, '0', satellites_fsk_demodulator_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_lucky7_deframer_0, '0']
- [satellites_lucky7_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_lucky7_deframer_0, out, gsSDR_websocket_transfer_sink_1, in]

metadata:
  file_format: 1
