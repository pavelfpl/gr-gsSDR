options:
  parameters:
    author: Pavel Fiaal
    category: Custom
    generate_options: qt_gui
    id: gr_lucky_test
    output_language: python
    title: gr-lucky test
  states: {}

blocks:
- name: doppler
  id: variable
  parameters:
    value: freq
  states: {}
- name: freq
  id: variable
  parameters:
    value: 437.525e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq-doppler
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lucky-7.iq
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: doppler
  states: {}
- name: gsSDR_gs_doppler_correction_0
  id: gsSDR_gs_doppler_correction
  parameters:
    ServerName: localhost
    ServerPort: '4532'
    sourceType: '0'
  states: {}
- name: gsSDR_http_transfer_sink_0
  id: gsSDR_http_transfer_sink
  parameters:
    ServerName: localhost
    ServerPort: '8080'
    ServerTarget: /gs/tm
    UserName: ''
    UserPass: ''
    spacecraftId: '0'
    stationId: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '4800'
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}
- name: satellites_lucky7_deframer_0
  id: satellites_lucky7_deframer
  parameters:
    threshold: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '85'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', satellites_fsk_demodulator_0, '0']
- [gsSDR_gs_doppler_correction_0, out, blocks_message_debug_0, print]
- [gsSDR_gs_doppler_correction_0, out, gpredict_MsgPairToVar_0, inpair]
- [satellites_fsk_demodulator_0, '0', satellites_lucky7_deframer_0, '0']
- [satellites_lucky7_deframer_0, out, blocks_message_debug_0, print_pdu]
- [satellites_lucky7_deframer_0, out, gsSDR_http_transfer_sink_0, in]
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
