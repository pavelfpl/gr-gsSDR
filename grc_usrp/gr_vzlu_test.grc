options:
  parameters:
    author: Pavel Fiala
    category: Custom
    generate_options: qt_gui
    id: gr_vzlu_test
    output_language: python
    run_options: run
    title: gr-vzlu test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 437.242e6
  states: {}
- name: gain_set
  id: variable
  parameters:
    value: '40'
  states: {state: disabled}
- name: gain_set
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: waterfall_set_max
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-90'
    step: '1'
    stop: '-30'
    value: '-55'
  states: {}
- name: waterfall_set_min
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-130'
    step: '1'
    stop: '-60'
    value: '-85'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: lucky-7.iq
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: gsSDR_gs_doppler_correction_0
  id: gsSDR_gs_doppler_correction
  parameters:
    ServerName: localhost
    ServerPort: '4534'
    baseFrequency: freq
    sourceType: '1'
  states: {}
- name: gsSDR_http_transfer_sink_0
  id: gsSDR_http_transfer_sink
  parameters:
    ServerName: localhost
    ServerPort: '8080'
    ServerTarget: /gs/tm
    UserName: ''
    UserPass: ''
    spacecraftId: '2'
    stationId: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '0.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    int_max: waterfall_set_max
    int_min: waterfall_set_min
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: '3600'
    baudrate: '4800'
    deviation: '-1200'
    iq: 'True'
    samp_rate: samp_rate
  states: {}
- name: satellites_u482c_deframer_0
  id: satellites_u482c_deframer
  parameters:
    threshold: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain_set
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', satellites_afsk_demodulator_0, '0']
- [gsSDR_gs_doppler_correction_0, out_rx, analog_sig_source_x_0, freq]
- [gsSDR_gs_doppler_correction_0, out_rx, blocks_message_debug_1, print]
- [satellites_afsk_demodulator_0, '0', satellites_u482c_deframer_0, '0']
- [satellites_u482c_deframer_0, out, blocks_message_debug_0, print]
- [satellites_u482c_deframer_0, out, gsSDR_http_transfer_sink_0, in]
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
