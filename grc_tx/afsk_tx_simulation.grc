options:
  parameters:
    author: Pavel Fiala
    generate_options: qt_gui
    id: afsk_tx_simulation
    output_language: python
    title: afsk_tx_simulation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: samp_rate_audio*4
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate_audio
    fh: '-1.0'
    max_dev: 3e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '4'
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/pavelf/gnuradio_addons_3.8/gr-gsSDR/build/ping.wav
    samp_rate: samp_rate_audio
  states: {state: disabled}
- name: gsSDR_afsk_basic_0
  id: gsSDR_afsk_basic
  parameters:
    baud_rate: '1200'
    mark_freq: '1200'
    preamble_len_ms: '0.0'
    samp_rate: samp_rate_audio
    space_freq: '1800'
    stream_tag: packet_len
  states: {}
- name: gsSDR_build_packet_1_0
  id: gsSDR_build_packet_1
  parameters:
    appendHeader: 'False'
    dataFrom: '2'
    dataType: '1'
    filename: ''
    packetLength: '64'
    packet_bytes_h: '[0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0x55,0xC3,0xAA,0x66,0x55,0xCE,0xC6,0x25,0x6B,0x58,0x71,0xC0,0x9A,0x26,0x60,0x68,0xA4,0x8B,0x09,0x2A,0xB1,0xFD,0xA4,0x74,0xC0,0x89,0xAC,0x28,0x01,0xA0,0x8A,0xD3,0xB8,0x90,0x94,0xB7,0xA2,0xE0,0xBA,0xE6,0xF2,0xFE,0x2A,0x19,0xB4,0x55,0x55] '
  states: {}
- name: gsSDR_packed_to_unpacked_0
  id: gsSDR_packed_to_unpacked
  parameters: {}
  states: {state: bypassed}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 12.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 6.25e3
    win: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '32768'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: 32768*4
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
  states: {}

connections:
- [analog_nbfm_tx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_message_strobe_0, strobe, gsSDR_build_packet_1_0, pdus]
- [blocks_tagged_stream_multiply_length_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0, '0']
- [gsSDR_afsk_basic_0, '0', analog_nbfm_tx_0, '0']
- [gsSDR_afsk_basic_0, '0', blocks_wavfile_sink_0, '0']
- [gsSDR_afsk_basic_0, '0', qtgui_time_sink_x_0, '0']
- [gsSDR_build_packet_1_0, out_pdus, gsSDR_packed_to_unpacked_0, pdus]
- [gsSDR_packed_to_unpacked_0, pdus_out, blocks_message_debug_0, print]
- [gsSDR_packed_to_unpacked_0, pdus_out, gsSDR_afsk_basic_0, in]
- [low_pass_filter_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
